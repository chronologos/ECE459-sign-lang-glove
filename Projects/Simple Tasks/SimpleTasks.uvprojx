# Keil uVision project SimpleTasks.uvprojx, settings and files
target mbed LPC1768 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SimpleTasks
  AfterMake: fromelf --bin -o E:\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_LPC1768
  c include: ..\..\mbed;..\..\mbed\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\mbed\LPC1768\LPC1768.sct
  link misc: ..\..\mbed\LPC1768\startup_LPC17xx.o
..\..\mbed\LPC1768\system_LPC17xx.o
..\..\mbed\LPC1768\stackheap.o
..\..\mbed\LPC1768\core_cm3.o
..\..\mbed\LPC1768\cmsis_nvic.o
..\..\mbed\LPC1768\capi.ar
..\..\mbed\LPC1768\mbed.ar
  group User files
    ./: main.cpp part2_blinkingLED.txt part3_pollingLED.txt part4_interruptLED.txt part5_exampleSchedulerLEDs.txt part6.txt part7_changed_priorities.txt
  group Nano_RK
    ../../mrk/src/drivers/platform/: adc_driver.cpp ff_basic_sensor.cpp
    ../../mrk/src/kernel/hal/: nrk_cpu.cpp nrk_ext_int.cpp nrk_status.cpp nrk_timer.cpp nrk_watchdog.cpp
    ../../mrk/src/kernel/source/: nrk.cpp nrk_driver.cpp nrk_error.cpp nrk_events.cpp nrk_idle_task.cpp nrk_reserve.cpp nrk_scheduler.cpp nrk_stack_check.cpp nrk_stats.cpp nrk_sw_wdt.cpp nrk_task.cpp nrk_time.cpp
    ../../mrk/src/platform/: hal_wait.cpp nrk_eeprom.cpp ulib.cpp
    ../../mrk/: my_asm.s
